# Keil uVision project obdh.uvproj, settings and files
target Target 1 (MCS-51)
  device: C8051F120 Silicon Laboratories, Inc.
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFFF) CLOCK(100000000) MDU_F120
  output: obdh +hex
  c flags: SizeSpeed=1
  group Group1
    ./: C8051_adc.c C8051_delay.c C8051_mcutemp.c C8051_oscillator.c C8051_SMBus.c C8051_SMBusSpy.c C8051_SMBusTimer3.c C8051_SPI0.c C8051_SPI0_int.c C8051_SPI0_shared.c C8051_uart0.c C8051_UART0Timer4.c C8051_uart1.c C8051_UART1Timer1.c C8051_watchdog.c comm_generic.c comm_imc.c comm_itc.c comm_itc_cw.c hash_blob.c hash_frame.c hash_manifest.c mccif_active.c mccif_buffer.c mccif_local.c mccif_spy.c mccif_stream.c mccif_xdata.c obdh_auth.c obdh_constant.c obdh_cqt.c obdh_debug.c obdh_events.c obdh_globalvariables.c obdh_grace.c obdh_main.c obdh_port.c obdh_recon.c obdh_schedule.c obdh_systemconfig.c obdh_systeminit.c obdh_timer.c obdh_timekeeper.c obdh_trxuv.c rtc_generic.c sdcard_generic.c sdcard_redundant.c state_adcsHk.c state_cmdHandler.c state_downlink.c state_ferryCct.c state_ferryGps.c state_ferryXBee.c state_powerCqt.c state_pwrsHk.c state_radioUp.c state_rtcSync.c state_scheduler.c state_trxuvHk.c state_util.c state_wireUp.c state_xdatSegGet.c Velox_beacon.c Velox_calendar.c Velox_checksum.c Velox_clock.c Velox_delay.c Velox_meta.c Velox_rtc_support.c Velox_runtime.c Velox_screen.c Velox_seconds.c Velox_slowtask.c Velox_sfrstack.c Velox_state.c Velox_timertask.c Velox_uart.c Velox_uptime.c Velox_watchdog.c
